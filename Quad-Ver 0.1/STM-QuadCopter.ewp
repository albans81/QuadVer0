# IAR project STM-QuadCopter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; ECHOMODE; USE_USB_OTG_FS; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: user\; STM32F4xx_StdPeriph_Driver\inc\; STM32F4-Discovery\; CMSIS; STM32_USB_Device_Library\Core\inc; STM32_USB_Device_Library\Class\cdc\inc; STM32_USB_Device_Library\User; STM32_USB_Device_Library\Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM-QuadCopter.srec
  ILINK.IlinkOutputFile: STM-QuadCopter.out
  ILINK.IlinkIcfFile: user\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Start-Up
    user/: startup_stm32f4xx.s
  group STM32F4-Discovery
    STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriph_Driver
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group USB Device/Class/CDC
    STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Library
    STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Device/User
    STM32_USB_Device_Library/User/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group USB Drivers
    STM32_USB_Device_Library/Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    user/: main.c stm32f4xx_it.c system_stm32f4xx.c
